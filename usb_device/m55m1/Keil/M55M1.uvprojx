# Keil uVision project M55M1.uvprojx, settings and files
target FullSpeed (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: cdc_msc
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: xCONFIG_USB_HS,xCONFIG_USB_DBG_LEVEL=USB_DBG_LOG,_project=0
  c include: ..\BSP\Library\CMSIS\Core\Include;..\BSP\Library\Device\Nuvoton\M55M1\Include;..\BSP\Library\StdDriver\inc;..\..\..\CherryUSB\core;..\..\m55m1;..\..\..\CherryUSB\common;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\BSP\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x4000"
  group CMSIS
    ../BSP/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Library
    ../BSP/Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c
  group User
    ../: main.c usb_config.h
    ../../../CherryUSB/demo/: cdc_acm_msc_template.c msc_ram_template.c cdc_rndis_template.c hid_mouse_template.c
  group CherryUSB
    ../../../CherryUSB/core/: usbd_core.c
    ../../../CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../../../CherryUSB/class/hid/: usbd_hid.c
    ../../../CherryUSB/class/msc/: usbd_msc.c
  group driver
    ../cherryUSB_driver/: usb_dc_usbfs.c usb_dc.c usb_dc_usbhs.c
    ../../../CherryUSB/port/nuvoton/: usb_dc_usbfs_cherryUSB.c
target cherry (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: as above
  output: cdc_msc
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: xCONFIG_USB_HS,xCONFIG_USB_DBG_LEVEL=USB_DBG_LOG,_project=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\BSP\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x4000"
target highspeed (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.1.0.1
  cpu: as above
  output: cdc_msc
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CONFIG_USB_HS,xCONFIG_USB_DBG_LEVEL=USB_DBG_LOG,CONFIG_USBDEV_MAX_BUS=2,__project=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\BSP\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  link misc: --pd="-DSTACK_SIZE=0x1000" --pd="-DHEAP_SIZE=0x4000"
